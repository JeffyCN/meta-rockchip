../../poky/meta/classes/features_check.bbclass