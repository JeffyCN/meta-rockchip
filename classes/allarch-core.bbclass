../../poky/meta/classes/allarch.bbclass