# Copyright (C) 2019, Fuzhou Rockchip Electronics Co., Ltd
# Released under the MIT license (see COPYING.MIT for the terms)

CACHED_CONFIGUREVARS:class-native = " FORCE_UNSAFE_CONFIGURE=1"
