# Copyright (C) 2026, Rockchip Electronics Co., Ltd
# Released under the MIT license (see COPYING.MIT for the terms)

HOST_CXXFLAGS:append = " -Wno-deprecated-declarations"
BUILD_CXXFLAGS:append = " -Wno-deprecated-declarations"
